options:
  parameters:
    generate_options: qt_gui
    id: caci_rtl_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: digital.constellation_qpsk().base()
    modulus: '1'
    step_size: '0.01'
    type: cma
  states: {}
- name: agc_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: '"AGC Rate"'
    start: '1e-5'
    step: '1e-5'
    stop: '1e-2'
    value: '1e-4'
  states: {}
- name: agc_ref
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: '"AGC Ref"'
    start: '0.1'
    step: '0.1'
    stop: '2.0'
    value: '1.0'
  states: {}
- name: corr_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: '"Sync Threshold"'
    rangeType: int
    start: '0'
    step: '1'
    stop: '6'
    value: '2'
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: '"Costas BW"'
    start: '0.001'
    step: '0.001'
    stop: '0.05'
    value: '0.025'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fll_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"FLL BW"'
    start: '0.001'
    step: '0.001'
    stop: '0.05'
    value: '0.0125'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pfb_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"PFB BW"'
    start: '0.001'
    step: '0.001'
    stop: '0.05'
    value: '0.02'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"Rx Gain"'
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_qpsk().base()
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: '"packet_len"'
    threshold: corr_threshold
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: fll_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: pfb_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import os, sys, subprocess
      from gnuradio import gr
      import pmt

      JPEG_START = b"\xFF\xD8"
      JPEG_END   = b"\xFF\xD9"

      class blk(gr.basic_block):
          def __init__(self, out_jpg="recovered.jpeg", show=True):
              gr.basic_block.__init__(self, name="jpeg_recover_show_exit",
                                      in_sig=None, out_sig=None)

              self.message_port_register_in(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self._handle)

              self.out_jpg = out_jpg
              self.show = show

              self.buf = bytearray()
              self.done = False

          def _handle(self, msg):
              if self.done:
                  return

              # msg is a PDU: (meta, u8vector)
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)
              data = bytes(pmt.u8vector_elements(vec))

              self.buf.extend(data)

              s = self.buf.find(JPEG_START)
              if s < 0:
                  return
              e = self.buf.find(JPEG_END, s)
              if e < 0:
                  return

              jpg = bytes(self.buf[s:e+2])

              # Validate (strong if Pillow exists; otherwise marker-only)
              if not self._valid_jpeg(jpg):
                  # likely false marker due to noise; advance and keep searching
                  del self.buf[:s+2]
                  return

              with open(self.out_jpg, "wb") as f:
                  f.write(jpg)

              print(f"[OK] JPEG saved: {self.out_jpg} ({len(jpg)} bytes)")

              if self.show:
                  self._open_image(self.out_jpg)

              self.done = True

              # HARD EXIT to guarantee flowgraph stops (works on Windows)
              os._exit(0)

          def _valid_jpeg(self, b):
              if len(b) < 4 or b[:2] != JPEG_START or b[-2:] != JPEG_END:
                  return False
              try:
                  from PIL import Image
                  import io
                  im = Image.open(io.BytesIO(b))
                  im.verify()
                  return True
              except Exception:
                  # fallback: accept marker-only
                  return True

          def _open_image(self, path):
              try:
                  if sys.platform.startswith("win"):
                      os.startfile(os.path.abspath(path))
                  elif sys.platform.startswith("darwin"):
                      subprocess.Popen(["open", path])
                  else:
                      subprocess.Popen(["xdg-open", path])
              except Exception as ex:
                  print(f"[WARN] Could not open image: {ex}")
    out_jpg: '''recovered1.jpg'''
    show: 'True'
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.45e9
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}

connections:
- [analog_agc_xx_0_0, '0', digital_fll_band_edge_cc_0_0, '0']
- [analog_agc_xx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_0_0, pdus]
- [uhd_usrp_source_0, '0', analog_agc_xx_0_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', digital_crc32_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
